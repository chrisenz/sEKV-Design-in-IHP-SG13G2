Simulation of the CS stage designed with the corresponding Jupyter Notebook

.lib /Simulations/models/cornerMOSlv.lib mos_tt
.include CS_GBW.op.par ; Size and bias values
.include CS_GBW.net ; Circuit netlist

.control
 save @n.x1.Nsg13_lv_pmos[ids] @n.x1.Nsg13_lv_pmos[gm] @n.x1.Nsg13_lv_pmos[gds] @n.x1.Nsg13_lv_pmos[cgdol] @n.x1.Nsg13_lv_pmos[cgsol] @n.x1.Nsg13_lv_pmos[lp_cgov]  @n.x1.Nsg13_lv_pmos[lp_cfr] @n.x1.Nsg13_lv_pmos[cjd] @n.x1.Nsg13_lv_pmos[cjdbot] @n.x1.Nsg13_lv_pmos[cjdgat] @n.x1.Nsg13_lv_pmos[cjdsti] @n.x1.Nsg13_lv_pmos[cjosbot] @n.x1.Nsg13_lv_pmos[cjossti] @n.x1.Nsg13_lv_pmos[cjosgat] @n.x1.Nsg13_lv_pmos[fug]
 save @n.x2.Nsg13_lv_pmos[ids] @n.x2.Nsg13_lv_pmos[gm] @n.x2.Nsg13_lv_pmos[gds] @n.x2.Nsg13_lv_pmos[cgdol] @n.x2.Nsg13_lv_pmos[cgsol] @n.x2.Nsg13_lv_pmos[lp_cgov]  @n.x2.Nsg13_lv_pmos[lp_cfr] @n.x2.Nsg13_lv_pmos[cjd] @n.x2.Nsg13_lv_pmos[cjdbot] @n.x2.Nsg13_lv_pmos[cjdgat] @n.x2.Nsg13_lv_pmos[cjdsti] @n.x2.Nsg13_lv_pmos[cjosbot] @n.x2.Nsg13_lv_pmos[cjossti] @n.x2.Nsg13_lv_pmos[cjosgat] @n.x2.Nsg13_lv_pmos[fug]
 op
 wrnodev $inputdir/CS_GBW.op.ic
 set wr_singlescale
 set wr_vecnames
 wrdata $inputdir/CS_GBW.op.dat
 wrdata $inputdir/CS_GBW.op.dat @n.x1.Nsg13_lv_pmos[ids] @n.x1.Nsg13_lv_pmos[gm] @n.x1.Nsg13_lv_pmos[gds] @n.x1.Nsg13_lv_pmos[cgdol] @n.x1.Nsg13_lv_pmos[cgsol] @n.x1.Nsg13_lv_pmos[lp_cgov] @n.x1.Nsg13_lv_pmos[lp_cfr] @n.x1.Nsg13_lv_pmos[cjd] @n.x1.Nsg13_lv_pmos[cjdbot] @n.x1.Nsg13_lv_pmos[cjdgat] @n.x1.Nsg13_lv_pmos[cjdsti] @n.x1.Nsg13_lv_pmos[cjosbot] @n.x1.Nsg13_lv_pmos[cjossti] @n.x1.Nsg13_lv_pmos[cjosgat] @n.x1.Nsg13_lv_pmos[fug]
 set appendwrite
 wrdata $inputdir/CS_GBW.op.dat @n.x2.Nsg13_lv_pmos[ids] @n.x2.Nsg13_lv_pmos[gm] @n.x2.Nsg13_lv_pmos[gds] @n.x2.Nsg13_lv_pmos[cgdol] @n.x2.Nsg13_lv_pmos[cgsol] @n.x2.Nsg13_lv_pmos[lp_cgov] @n.x2.Nsg13_lv_pmos[lp_cfr] @n.x2.Nsg13_lv_pmos[cjd] @n.x2.Nsg13_lv_pmos[cjdbot] @n.x2.Nsg13_lv_pmos[cjdgat] @n.x2.Nsg13_lv_pmos[cjdsti] @n.x2.Nsg13_lv_pmos[cjosbot] @n.x2.Nsg13_lv_pmos[cjossti] @n.x2.Nsg13_lv_pmos[cjosgat] @n.x2.Nsg13_lv_pmos[fug]
.endc
.end
